# Keil uVision project boot_ram.uvprojx, settings and files
target Boot_ram (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: boot_ram_download +hex
  AfterMake: fromelf --bin --output=boot_ram.bin .\Objects\%L
  AfterMake: fromelf -c -a -d -e -v -o boot_ram.asm .\Objects\%L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG HW_BX_VERSION=00
  c include: ..\..\..\..\app\config;..\..\..\..\ip;..\..\..\inc\cmsis\;..\..\..\;..\..\;..\;.\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\armcc\boot_ram_link.txt
  link misc: --entry=boot_ram_entry
  group Core
    ./: boot_ram.c dma_for_qspi.c flash.c qspi.c adc_battery.c
